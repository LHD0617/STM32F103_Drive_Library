# Keil uVision project STM32F103_Drive.uvprojx, settings and files
target STM32F103_Drive (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: STM32F103_Drive +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32F103xB
  c include: ../Core/Inc;../Drivers/Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MDK-ARM
    ./: startup_stm32f103xb.s
  group Core
    ../Core/Src/: main.c stm32f1xx_it.c system_stm32f1xx.c
  group Drivers
    ../Drivers/Src/: gpio.c
software components: CMSIS:CORE 4.3.0
